Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:06:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:06:15 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{9954AC8A-6E7B-4EED-81CA-59FC344B15E6}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:06:13 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:06:14 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:06:14 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: 10 L, Gaz naturel – Volume tampon:10 L:207311
In: Niveau 1
Type - Material: Jaune ALU
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Volume tampon
Type - Contraintes(Type) - Volume: 10 m3
Type - Données d'identification(Type) - Nom du type: 10 L
Pset_DistributionFlowElementCommon - Reference: 10 L
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Volume tampon: 10 L; Famille et type: Gaz naturel – Volume tampon: 10 L; ID du type: Gaz naturel – Volume tampon: 10 L; Type: Gaz naturel – Volume tampon: 10 L
Contraintes - Décalage: 0 mm; Diamétre J: 156 mm; DN: 25 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur L: 606 mm; Materiaux: Jaune ALU; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - A: 564 mm; B: 450 mm; E: 75 mm; G: 32 mm; H: 10 mm; I: 120 mm; L-A2: 21 mm; LARG_F: 28 mm; LARG PAT: 25 mm; Surface: 0.201699 m2; Taille: 32 mmø-32 mmø-25 mmø-25 mmø; Taille maximale: 32 mm; Taille minimale: 25 mm; Volume: 0.009673 m3
Données d'identification - Identifiant: 22
Génie climatique - Classification du système: Non défini,Alimentation hydraulique
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 32 mmø-32 mmø-25 mmø-25 mmø
Phase de construction - Phase de création: Nouvelle construction
